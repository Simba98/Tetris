# Keil uVision project PSetControl.uvproj, settings and files
target PSetControl (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Tetris_HC +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\GlobalHeader;..\GlobalTimer;..\Delay;..\74H595;..\LEDDisPlay;..\DigitronDisPlay;..\KeyScan;..\DisPlay;..\Tetris;..\Buzzer
  group startup
    ./: STARTUP.A51
  group header
    ../GlobalHeader/: STDHeader.h bitops.h S51Kernel.h SimbaTypeDef.h Sreg52.h
  group source
    ./: main.c
    ../74H595/: 74H595.c
    ../GlobalTimer/: TimerMain.c
    ../DisPlay/: DisPlay.c
    ../LEDDisPlay/: LEDDisPlay.c
    ../DigitronDisPlay/: DigitronDisPlay.c
    ../KeyScan/: KeyScan.c
    ../Tetris/: Tetris.c
    ../Buzzer/: Buzzer.c
